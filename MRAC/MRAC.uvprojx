# Keil uVision project MRAC.uvprojx, settings and files
target Core (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MRAC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MRAC\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./MRAC/Src/: delay.c encoder_analog.c gpio_driver.c main.c mrac_controller.c usart_driver.c
  group Inc
    ./MRAC/Inc/: usart_driver.h delay.h encoder_analog.h gpio_driver.h mrac_controller.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
